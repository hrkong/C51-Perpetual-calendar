# Keil uVision project DS1302_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: DS1302_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../../../../51 DHT/: dhtXX.c ds1302.c LCD12864.C main.c dhtXX.h ds1302.h LCD12864.h
