# Keil uVision project DS1302_3.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: DS1302_3 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c dhtXX.c ds1302.c LCD12864.C key.c beep.c ds1302.h LCD12864.h dhtXX.h key.h beep.h
